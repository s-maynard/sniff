
FILESEXTRAPATHS_prepend := "${THISDIR}/init-ifupdown:"

SRC_URI += "\
    file://interfaces \
"

